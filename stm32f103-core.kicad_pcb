# Repository louiscklaw/stm32f103-core

## KiCad design stm32f103-core.kicad_pcb

Parts:
BOOT0, BOOT1: SolderJumper_3_Open; SolderJumper-3_P2.0mm_Open_TrianglePad1.0x1.5mm
C1, C2, C3, C4, C8: C104; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C5, C6: TC106,10V; CP_EIA-3216-12_Kemet-S_Pad1.58x1.35mm_HandSolder
C7, C9: C105; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C10, C11, C12, C13: C20pf; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D3: LED_GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: LED_ORANGE; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_01x14; PinHeader_1x14_P1.27mm_Vertical
J3: Conn_01x12; PinHeader_1x12_P1.27mm_Vertical
J4: Conn_01x12; PinHeader_1x20_P1.27mm_Vertical
JP3: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1, R2: R104; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3, R5, R6: R511; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: R103; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1: SW_Push; SW_SPST_CK_RS282G05A3
U1: STM32F103C8T6; LQFP-48_7x7mm_P0.5mm
U2: AMS1117-3.3; SOT-223-3_TabPin2
Y1: O8M; hc-49_smd
Y2: O32.768K; MC-306

Connections:
+3V3: BOOT0.1 (A), BOOT1.1 (A), C1.1, C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, D1.2 (A), D2.2 (A), J1.1, J4.3, R4.1, U1.1 (VBAT), U1.9 (VCC3V3), U1.24 (VDD_1), U1.36 (VDD_2), U1.48 (VCC3V3), U2.2 (VO)
+5V: C5.1, JP3.2, U2.3 (VI)
/BOOT0: R1.2, U1.44 (BOOT0)
/BOOT1: R2.1, U1.20 (PB2/BOOT1)
/OSCIN: C11.1, U1.5 (OSCIN), Y1.2
/OSCOUT: C10.1, U1.6 (OSCOUT), Y1.1
/PA0: J4.9, U1.10 (PA0)
/PA1: J4.10, U1.11 (PA1)
/PA2: J4.11, U1.12 (PA2)
/PA3: J4.12, U1.13 (PA3)
/PA4: J4.13, U1.14 (PA4)
/PA5: J4.14, U1.15 (PA5)
/PA6: J4.15, U1.16 (PA6)
/PA7: J4.16, U1.17 (PA7)
/PA8: J3.5, U1.29 (PA8)
/PA9: J3.6, U1.30 (PA9)
/PA10: J3.7, U1.31 (PA10)
/PA11: J3.8, U1.32 (PA11)
/PA12: J3.9, U1.33 (PA12)
/PA15: J1.5, U1.38 (PA15)
/PB0: J4.17, U1.18 (PB0)
/PB1: J4.18, U1.19 (PB1)
/PB3: J1.6, U1.39 (PB3)
/PB4: J1.7, U1.40 (PB4)
/PB5: J1.8, U1.41 (PB5)
/PB6: J1.9, U1.42 (PB6)
/PB7: J1.10, U1.43 (PB7)
/PB8: J1.11, U1.45 (PB8)
/PB9: J1.12, U1.46 (PB9)
/PB10: J4.19, U1.21 (PB10)
/PB11: J4.20, U1.22 (PB11)
/PB12: J3.1, U1.25 (PB12)
/PB13: J3.2, U1.26 (PB13)
/PB14: J3.3, U1.27 (PB14)
/PB15: J3.4, U1.28 (PB15)
/PC13: D3.2 (A), J1.14, U1.2 (PC13)
/PC14: C13.1, U1.3 (PC14), Y2.4
/PC15: C12.1, U1.4 (PC15), Y2.1
/RESET: C9.1, R4.2, SW1.2, U1.7 (RESET)
/SWCLK: J1.3, U1.37 (SWCLK)
/SWIO: J1.2, U1.34 (SWIO)
GND: BOOT0.3 (B), BOOT1.3 (B), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.4, J4.2, R3.2, R5.2, R6.2, SW1.1, U1.8 (GND), U1.23 (VSS_1), U1.35 (VSS_2), U1.47 (GND), U2.1 (GND)
unnamed: BOOT0.2 (C), R1.1
unnamed: BOOT1.2 (C), R2.2
unnamed: D1.1 (K), R3.1
unnamed: D2.1 (K), R5.1
unnamed: D3.1 (K), R6.1
unnamed: J4.1, JP3.1

Board: 2 copper layers, 30.0 x 35.0 mm, 33 parts (0 on the bottom side), 48 nets.

## KiCad design stm32f103_core.kicad_pcb

Board: 2 copper layers, 78 parts (0 on the bottom side), 42 nets, no tracks yet.

Parts:
C1, C2, C8, C9, C10, C11, C12, C13, C15, C19, C20, C25, C27: 104; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3, C24: 475; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C4, C5: 200; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C6, C7: 150; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C14: 106; CP_Elec_4x3.9
C16: 014; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C17: 104; CP_Elec_4x3.9
C18, C21: 105; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C22: 106; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C23: CP; CP_Elec_3x5.3
C26: C; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3, D4, D5, D6, D11: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D7, D8: PWR; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D9, D10: 1N5824; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D12: TX_ACT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D13: RX_ACT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: JMP_USER_BTN_EN; SW_PUSH_6mm_H4.3mm
J2: USB_A; PinHeader_1x05_P2.54mm_Vertical
J3: Conn_02x01; Pin_Header_Straight_1x02_Pitch2.54mm
R1, R6, R7, R17, R18, R19, R20, R25: R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2: 472; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R3: 0R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4, R5: 100; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R8, R26, R27: 22R; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R9, R11, R12, R14, R21, R24: 0; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R10, R29: 152; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R13, R22, R23, R30, R31: 103; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R28: 104; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1: RESET_BTN; SW_SPST_FSMSM
SW2: USER_BTN; SW_SPST_FSMSM
U1: STM32F103RBT6; QFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm
U3: AMS1117-5.0; SOT-223-3_TabPin2
U4: LD3985M33R_SOT23; SOT-23-5
U5: CP2102GMR; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm_ThermalVias
Y1: 8M; hc-49_smd
Y2: 32.768K; crystal_smd_ma-505

Connections:
+3V3: R30.1, R31.1
/CP2102/RXD: D13.1, U5.25
/CP2102/TXD: D12.1, U5.26
/CP2102/USB_DM: R27.1, U5.5
/CP2102/USB_DP: R26.1, R29.2, U5.4
/NRST: C1.1, SW1.1, U1.7
/PA12: R8.1, U1.45
/PB1: R6.1, R7.1, R7.2, U1.27
/PB11: C3.1, U1.30
/PC13: J1.2, U1.2
/PF0: R9.1, R12.1, U1.5
/PF1: R11.1, R14.1, U1.6
/USBDP: J2.3, R8.2, R10.1
AVDD: C13.1, R6.2, R21.1, U1.13
GND: C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D11.1, J2.4, J2.5, R1.2, R4.2, R5.2, R24.2, R28.2, SW1.2, SW2.2, U1.18, U1.31, U1.47, U3.1, U4.2, U5.3, U5.29
unnamed: C1.2, R4.1
unnamed: C2.1, J1.1, R2.2, SW2.1
unnamed: C2.2, R5.1
unnamed: C4.1, R9.2, Y1.1
unnamed: C5.1, R11.2, Y1.2
unnamed: C6.1, R12.2, Y2.1
unnamed: C7.1, R14.2, Y2.2
unnamed: C13.2, R24.1
unnamed: C14.1, C15.1, D9.1, U3.3
unnamed: C16.1, C17.1, D10.2, U3.2
unnamed: C18.1, C19.1, U4.5
unnamed: C20.1, C21.1, R25.1, U4.1, U4.3
unnamed: C22.1, U4.4
unnamed: C23.1, C26.1, U5.6
unnamed: D3.2, R17.2
unnamed: D4.2, R18.2
unnamed: D5.2, R19.2
unnamed: D6.2, R20.2
unnamed: D7.2, R22.2
unnamed: D8.2, R23.2
unnamed: D11.2, R25.2
unnamed: D12.2, R30.2
unnamed: D13.2, R31.2
unnamed: J3.1, R13.1
U5V: C24.1, C25.1, C27.1, R23.1, R29.1, U5.7, U5.8, U5.9
VBAT: C8.1, R3.1, R22.1, U1.1
VDD: C9.1, C10.1, C11.1, C12.1, R2.1, R3.2, R21.2, U1.19, U1.32, U1.48

## Commit log

2018-10-08 update,
2020-05-05 ci: init travis build config,
2020-05-05 ci: init travis token,
